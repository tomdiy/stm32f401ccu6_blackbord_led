<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32f401ccu6_black_001_led.ewp</path>
  </project>
  <batchBuild />
</workspace>
